options:
  parameters:
    generate_options: qt_gui
    id: Modulador_PWM
    output_language: python
    title: Modulador_PWM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud dientes sierra
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '2'
  states: {}
- name: Cte
  id: variable_qtgui_range
  parameters:
    label: Constante
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: DC
  id: variable_qtgui_range
  parameters:
    label: Nivel de continua dientes sierra
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 5e7
    step: 1e6
    stop: 1e9
    value: 5e7
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '100'
    step: '10'
    stop: '1000'
    value: '200'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: frecuencia dientes sierra
    start: '100'
    step: '10'
    stop: '10000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: fm
    offset: Cte
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: fs
    offset: DC-A/2
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    nconnections: '3'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', blocks_float_to_complex_0, '0']
- [ModulosEfren_Compara_0, '0', qtgui_freq_sink_x_0, '0']
- [ModulosEfren_Compara_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0_0, '0', ModulosEfren_Compara_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle_0, '0', ModulosEfren_Compara_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
